# IAR project timer_a_ex3_continousModeOperationWithTAIEInterrupt.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEPRECATED
  ICC430.newCCIncludePaths: ../../../../driverlib/MSP430FR57xx; ../..
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  group (top)
    ../: timer_a_ex3_continousModeOperationWithTAIEInterrupt.c
  group driverlib/MSP430FR57xx
    ../../../../driverlib/MSP430FR57xx/: eusci_a_uart.c sysctl.h dma.c comp_d.c dma.h eusci_b_i2c.h rtc_b.h crc.h cs.h tlv.c mpy32.h timer_b.c eusci_b_spi.c framctl.h cs.c crc.c eusci_a_spi.c sfr.h wdt_a.h mpu.c timer_a.h pmm.h adc10_b.h sfr.c wdt_a.c eusci_a_uart.h driverlib.h gpio.h mpu.h mpy32.c tlv.h comp_d.h eusci_b_i2c.c rtc_b.c gpio.c ref.h framctl.c eusci_a_spi.h timer_b.h pmm.c ref.c adc10_b.c eusci_b_spi.h sysctl.c timer_a.c
  group driverlib/MSP430FR57xx/inc
    ../../../../driverlib/MSP430FR57xx/inc/: hw_memmap.h version.h

# IAR project timer_a_ex2_continousModeOperationWithCCR0Interrupt.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ../../../../driverlib/MSP430FR5xx_6xx; ../..
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FR5969.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: DEPRECATED
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../: timer_a_ex2_continousModeOperationWithCCR0Interrupt.c
  group driverlib/MSP430FR5xx_6xx
    ../../../../driverlib/MSP430FR5xx_6xx/: eusci_a_uart.c hspll.h lcd_c.c sysctl.h dma.c dma.h eusci_b_i2c.h rtc_b.h crc.h adc12_b.h ram.c adc12_b.c rtc_c.c esi.h saph.h cs.h ram.h crc32.c tlv.c mtif.c mpy32.h crc32.h timer_b.c eusci_b_spi.c comp_e.h framctl.h aes256.h saph.c cs.c crc.c eusci_a_spi.c sfr.h wdt_a.h mpu.c saph_a.h timer_a.h pmm.h framctl_a.c rtc_c.h uups.h sfr.c wdt_a.c uups.c framctl_a.h aes256.c eusci_a_uart.h driverlib.h gpio.h mpu.h mpy32.c tlv.h hspll.c sdhs.h eusci_b_i2c.c rtc_b.c ref_a.c esi.c gpio.c framctl.c eusci_a_spi.h timer_b.h ref_a.h pmm.c eusci_b_spi.h saph_a.c comp_e.c mtif.h sysctl.c sdhs.c lcd_c.h timer_a.c
  group driverlib/MSP430FR5xx_6xx/inc
    ../../../../driverlib/MSP430FR5xx_6xx/inc/: hw_memmap.h version.h

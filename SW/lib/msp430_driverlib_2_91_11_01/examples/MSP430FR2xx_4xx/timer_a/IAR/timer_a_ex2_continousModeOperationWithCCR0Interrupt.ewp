# IAR project timer_a_ex2_continousModeOperationWithCCR0Interrupt.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR4133 MSP430FR4133
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ../../../../driverlib/MSP430FR2xx_4xx; ../..
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FR5969.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: DEPRECATED
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../: timer_a_ex2_continousModeOperationWithCCR0Interrupt.c
    ../../: Board.h
  group driverlib/MSP430FR2xx_4xx
    ../../../../driverlib/MSP430FR2xx_4xx/: tia.c eusci_a_uart.c rtc.h sysctl.h eusci_b_i2c.h crc.h lcd_e.h cs.h ecomp.h tlv.c icc.c mpy32.h sac.c timer_b.c eusci_b_spi.c framctl.h adc.h sac.h cs.c crc.c eusci_a_spi.c sfr.h wdt_a.h icc.h timer_a.h pmm.h sfr.c rtc.c wdt_a.c eusci_a_uart.h driverlib.h gpio.h lcd_e.c mpy32.c tlv.h tia.h eusci_b_i2c.c gpio.c adc.c framctl.c eusci_a_spi.h ecomp.c timer_b.h pmm.c eusci_b_spi.h sysctl.c timer_a.c
  group driverlib/MSP430FR2xx_4xx/rom_headers
    ../../../../driverlib/MSP430FR2xx_4xx/rom_headers/: rom_driverlib_fr2676.h
  group driverlib/MSP430FR2xx_4xx/inc
    ../../../../driverlib/MSP430FR2xx_4xx/inc/: hw_memmap.h version.h
